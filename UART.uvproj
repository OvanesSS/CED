# Keil uVision project UART.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F361 Silicon Labs
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) CLOCK(100000000)
  output: UART +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c c8051F360.INC
